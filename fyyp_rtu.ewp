# IAR project fyyp_rtu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\libc; components\usb; drivers; hal_drivers\CMSIS\Device\ST\STM32F4xx\Include; hal_drivers\CMSIS\Include; hal_drivers\STM32_USB_Device_Library\Class\CDC\Inc; hal_drivers\STM32_USB_Device_Library\Core\Inc; hal_drivers\STM32F4xx_HAL_Driver\Inc; newbee
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fyyp_rtu.hex
  ILINK.IlinkOutputFile: fyyp_rtu.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group components/usb
    components/usb/: usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group drivers
    drivers/: board.c drv_fyyp.c drv_iic.c drv_lpm.c drv_mempool.c drv_pin.c drv_rtcee.c drv_tevent.c drv_w25qxxx.c
  group hal_drivers/cmsis
    hal_drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    hal_drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group hal_drivers/periph_drivers
    hal_drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c
  group hal_drivers/usb/cdc
    hal_drivers/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group hal_drivers/usb/core
    hal_drivers/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group newbee
    newbee/: main.c stm32f4xx_it.c
  group rtthread/port
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group rtthread/src
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
